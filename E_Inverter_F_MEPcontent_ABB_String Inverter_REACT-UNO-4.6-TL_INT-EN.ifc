Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-07-20T10:14:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 20 10:14:22 2018 * Host: B3ROBRAWR2788 * Database: C:\Users\AVIT\AppData\Local\Temp\{1821EC9E-6D22-435D-A6F3-D7CE4E496B66}\ifc * Database version: 5507 * Database creation date: Fri Jul 20 10:14:19 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jul 20 10:14:20 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 20 10:14:20 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcElectricFlowStorageDevice: REACT-BATT-AP1 2kWh, E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared:REACT-BATT-AP1 2kWh:1303157
In: V00
Type - PredefinedType: BATTERY; Material: Color RGB 170-170-170, Color RGB 255-255-255, Color RGB 085-085-085
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 229 mm; Height: 740 mm; Width: 490 mm
Type - Identity Data - Custom: no; Article Description: Lithium-ion battery, Initial Capacity 2.4 kWh (nominal 2 kWh), Iron enclosure, to be used with REACT-UNO-3.6-TL or REACT-UNO-4.6-TL; Article Type: REACT-BATT-AP1 2kWh; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Description: Lithium-ion battery, Initial Capacity 2.4 kWh (nominal 2 kWh), Iron enclosure, to be used with REACT-UNO-3.6-TL or REACT-UNO-4.6-TL; EMCS Version: 4.0; ETIM Article Class: EC001757; Family Version: 11.15; GTIN: 8054529630714; Manufacturer: ABB; Manufacturer Art. No.: ABB6AGC003558; Manufacturer URL: http://new.abb.com/power-converters-inverters/solar/photovoltaic-energy-storage/react-and-freeathome; MEPcontent Class: BATTERY; Model: REACT-BATT-AP1 2kWh; OmniClass Number: 23.80.10.24.11; OmniClass Title: Batteries; Product Line: Battery unit; Revit Version: 2017; Short Description: 2 kWh battery; Type Name: REACT-BATT-AP1 2kWh; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Back Support: Color RGB 087-093-094; Box White: Color RGB 170-170-170; Button Black: Color RGB 042-042-042; Dark Grey: Color RGB 085-085-085; Grey Blue: Color RGB 141-149-155; Grill Grey: Color RGB 191-191-191; White: Color RGB 255-255-255; White Grey: Color RGB 200-200-200
Type - Other - Category: Electrical Equipment; Family Name: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared; Offset: 0 mm; Support: 600 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 0.637599 m2; Volume: 0.0607765 m3
Identity Data - Design Option: Main Model; Mark: 3
Other - Family: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared: REACT-BATT-AP1 2kWh; Family and Type: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared: REACT-BATT-AP1 2kWh; Type: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared: REACT-BATT-AP1 2kWh; Type Id: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO BATTERY_INT-EN_Shared: REACT-BATT-AP1 2kWh
Phasing - Phase Created: 3. Nieuwbouw

# IfcTransformer: REACT-UNO-4.6-TL, E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN:REACT-UNO-4.6-TL:1303156
In: V00
Type - PredefinedType: INVERTER; Material: Color RGB 042-042-042, Color RGB 200-200-200, Color RGB 255-255-255, Color RGB 141-149-155, Color RGB 085-085-085, Color RGB 255-000-000, Color RGB 170-170-170, Color RGB 191-191-191
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 229.3 mm; Height: 738 mm; Width: 490 mm
Type - Electrical - Loads - Rated AC Power: 4600 W
Type - Electrical Engineering - Absolute Maximum DC Voltage: 600 V; Average Capacity: 2kWh; Maximum DC Current: 27 A; Rated AC Grid Voltage: 230 V
Type - Identity Data - Article Description: Single phase hybrid inverter, 4600 Wac, 2 MPPT, storage ready with REACT-BATT-AP1; Article Type: REACT-UNO-4.6-TL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Single phase hybrid inverter, 4600 Wac, 2 MPPT, storage ready with REACT-BATT-AP1; EMCS Version: 4.0; ETIM Article Class: EC001747; Family Version: 11.17; GTIN: 8054529630707; Manufacturer: ABB; Manufacturer Art. No.: ABB6AGC003353; Manufacturer URL: http://new.abb.com/power-converters-inverters/solar/photovoltaic-energy-storage/react-and-freeathome; MEPcontent Class: INVERTER; Model: REACT-UNO-4.6-TL; OmniClass Number: 23.80.30.11.14; OmniClass Title: Inverters; Product Line: UNO; Revit Version: 2017; Short Description: Single phase hybrid inverter; Type Name: REACT-UNO-4.6-TL; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - Number of Independent MPPT: 2; Optimal Battery Operational Temperature Range: +5°C...+35°C
Type - Other - Category: Electrical Equipment; Family Name: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Elevation: 0 mm
Dimensions - Area: 0.669879 m2; Volume: 0.0594552 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-4600 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 2
Other - Family: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN: REACT-UNO-4.6-TL; Family and Type: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN: REACT-UNO-4.6-TL; Offset Battery: 494.5 mm; Two Batteries Safe: no; Type: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN: REACT-UNO-4.6-TL; Type Id: E_Inverter_F_MEPcontent_ABB_String Inverter_REACT UNO_INT-EN: REACT-UNO-4.6-TL
Phasing - Phase Created: 3. Nieuwbouw
Visibility - One Battery: yes; Three Batteries: no; Two Batteries: no
